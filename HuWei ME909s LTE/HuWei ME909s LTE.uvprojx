# Keil uVision project HuWei ME909s LTE.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K142HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x1FFFC000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuWei ME909s LTE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include;.\nxpLib;.\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: .\RTE\Device\S32K142HAxxxLHx\S32K142_32_flash.sct
  group src
    ./: main.c
    ./src/: mem909s.c mem909s.h
  group nxpliv
    ./nxpLib/: canbus.c canbus.h clocks_and_modes.c clocks_and_modes.h gpio.c gpio.h nxpQueue.c nxpQueue.h spi.c spi.h timer.c timer.h uart.c uart.h usertype.h
software components: CMSIS:CORE 5.2.0, Device:Startup 2.0.0
