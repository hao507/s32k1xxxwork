# Keil uVision project freeRTOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: S32K142HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x1FFFC000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
software components: CMSIS:CORE 5.2.0, Device:Startup 2.0.0
