# Keil uVision project nxp142_boot.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K142HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x1FFFC000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nxp142_boot +hex
  AfterMake: fromelf.exe --bincombined --output .\Objects\nxp142_boot.bin .\Objects\nxp142_boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src;.\nxpLib;.\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: .\RTE\Device\S32K142HAxxxLHx\S32K142_32_flash.sct
  group src
    ./src/: main.c updata.c updata.h
  group nxpLib
    ./nxpLib/: clocks_and_modes.c clocks_and_modes.h gpio.c gpio.h usertype.h uart.c uart.h nxpQueue.c nxpQueue.h pcc_hal.c pcc_hal.h flash_driver.c flash_driver.h timer.c timer.h
  group equipLIb
    ./equipLib/: wdgTps.c wdgTps.h
software components: CMSIS:CORE 5.1.2, Device:Startup 2.0.0
