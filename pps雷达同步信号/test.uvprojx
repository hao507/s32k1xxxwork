# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K116xxxxMFMx NXP
  pack: Keil.S32K116_SDK_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00002000) IRAM2(0x20002000,0x00001800) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src;.\include;.\nxplib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x1800
  scatter file: .\RTE\Device\S32K116xxxxMFMx\S32K116_17_flash_AC5.sct
  group src
    ./src/: clocks_and_modes_S32K11x.c LPUART_S32K11x.c main.c gpio.c gpio.h usertype.h nxpQueue.c nxpQueue.h FlexCAN.c FlexCAN.h
    ./nxplib/: timer.c timer.h FTM.c RTC.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
