# Keil uVision project nxp142_mcu_test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K142HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x1FFFC000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nxp142_app
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src;.\nxpLib;.\include;.\equipLib;.\power;.\power\S32K1xx;H:\Keil_v526\ARM\PACK\Keil\S32_SDK_DFP\1.2.0\platform\drivers\src\clock\S32K1xx;.\Generated_Code
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: .\RTE\Device\S32K142HAxxxLHx\S32K142_32_flash.sct
  group src
    ./src/: main.c Type0_mcu_Test.c Type1_mcu_Test.c Type2_mcu_Test.c updata.c
  group nxpLib
    ./nxpLib/: clocks_and_modes.c clocks_and_modes.h gpio.c gpio.h usertype.h uart.c uart.h nxpQueue.c nxpQueue.h timer.c timer.h watchdog.c watchdog.h powerMan.h powerMan.c printf.c printf.h powerManger.c powerManger.h canbus.c canbus.h
  group equipLib
    ./equipLib/: wdgTps.c wdgTps.h mem909s.c mem909s.h
  group Generated_Code
    ./Generated_Code/: clock.c clock.h lowPower.c lowPower.h config.h delay.h
software components: CMSIS:CORE 5.1.2, Device:Startup 2.0.0
