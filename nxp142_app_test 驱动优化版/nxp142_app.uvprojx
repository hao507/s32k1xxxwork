# Keil uVision project nxp142_app.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K142HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x1FFFC000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nxp142_app
  AfterMake: fromelf.exe --bincombined --bincombined_base=0x4000 --output .\Objects\nxp142app.bin .\Objects\nxp142_app.axf
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src;.\nxpLib;.\include;.\equipLib;.\power;.\power\S32K1xx;H:\Keil_v526\ARM\PACK\Keil\S32_SDK_DFP\1.2.0\platform\drivers\src\clock\S32K1xx;.\Generated_Code
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: .\RTE\Device\S32K142HAxxxLHx\S32K142_32_flash.sct
  group src
    ./src/: main.c mem909s.h updata.c updata.h Type0_mcu_Test.c Type0_mcu_Test.h Type1_mcu_Test.c Type1_mcu_Test.h mcu_power_massge.c mcu_power_massge.h Type2_mcu_Test.h Type2_mcu_Test.c
    C:/Users/Administrator/Desktop/s32k142----SRC/: mem909s.c
  group nxplib
    ./nxpLib/: canbus.c canbus.h clocks_and_modes.c clocks_and_modes.h flash_driver.c flash_driver.h gpio.c gpio.h nxpQueue.c nxpQueue.h pcc_hal.c pcc_hal.h powerMan.c powerMan.h powerManger.c powerManger.h printf.c printf.h spi.c spi.h timer.c timer.h uart.c uart.h usertype.h watchdog.c watchdog.h wdgTps.c wdgTps.h
software components: CMSIS:CORE 5.1.2, Device:Startup 2.0.0
