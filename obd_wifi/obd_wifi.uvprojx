# Keil uVision project obd_wifi.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K142HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x1FFFC000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: obd_wifi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\winc1500\src;.\winc1500;.\include;.\nxpLib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: .\RTE\Device\S32K142HAxxxLHx\S32K142_32_flash.sct
  group src
    ./: main.c winc_nxp.c
  group winc1500
    ./winc1500/src/: wf_asic.c wf_hif.c wf_ota.c wf_socket.c wf_spi.c wf_spi_flash.c wf_utils.c wf_wifi.c
    ./winc1500/: winc1500_mode_ap.c winc1500_provision_ap.c
    ./winc1500/winc1500_ap_scan/: ota_event_stub.c socket_event_stub.c wifi_event_stub.c winc1500_ap_scan.c
    ./winc1500/demo_support/: winc1500_support_stub.c
  group nxplib
    ./nxpLib/: clocks_and_modes.c gpio.c nxpQueue.c spi.c timer.c uart.c flash_driver.c pcc_hal.c printf.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.0.0
